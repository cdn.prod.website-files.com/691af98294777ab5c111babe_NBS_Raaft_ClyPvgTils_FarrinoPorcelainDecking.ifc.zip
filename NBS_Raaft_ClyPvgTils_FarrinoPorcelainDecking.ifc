Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-09-08T15:30:14
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.2.90.12 - Alternate UI 20.2.90.12
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Sep 08 15:30:14 2023 * Host: NCL-PI16 * Database: C:\Users\haye\AppData\Local\Temp\f009e499-445f-4cb8-a149-b52ddcf67cfd\5ee4408a-4d0a-458c-9b2b-163577a581b9\ifc * Database version: 5507 * Database creation date: Fri Sep 08 15:30:14 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Sep 08 15:30:14 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Sep 08 15:30:14 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
COBie - Category: Levels; Name: Level 0

# IfcCovering: Floor:NBS_Raaft_ClayPavingTiles_FarrinoPorcelainDecking_FarrinoCocoa, Floor:NBS_Raaft_ClayPavingTiles_FarrinoPorcelainDecking_FarrinoCocoa:221720
In: Level 0
Type - PredefinedType: FLOORING; Material: NBS_Raaft_ClayPavingTiles_FarrinoPorcelainDecking_FarrinoCocoa 26 mm
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: FLOORING
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_25_93_60_10:Clay paving tiles; Color: Beige,Brown,Grey,Silver,Other; Finish: Wood grain; Material: Porcelain; Shape: Rectangle; Size: 1202 x 141 x 26 mm; WarrantyDescription: 15 year; CodePerformance: ISO 10545-3, ISO 10545-7; Constituents: n/a; Description: Natural wood effect porcelain decking boards; DurationUnit: year; ExpectedLife: n/a; Features: Class A fire-rated, high abrasion and frost resistance, anti-slip, thermostable, highly resistant to stains; Grade: n/a; Manufacturer: enquiries@raaft.co; ModelNumber: n/a; ModelReference: n/a; Name: ClayPavingTiles_FarrinoPorcelainDecking_FarrinoCocoa_Raaft; NominalHeight: 26 mm; NominalLength: 1202 mm; NominalWidth: 141 mm; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_Raaft_ClayPavingTiles_FarrinoPorcelainDecking_FarrinoCocoa; ManufacturerName: Raaft; ManufacturerURL: www.raaft.co; ProductInformation: https://source.thenbs.com/product/-/2d21df91-2c1e-40e3-9def-9decae13e560/d00127ab-95ce-48b0-97fa-c07815e56af3; Uniclass2015Code: Pr_25_93_60_10; Uniclass2015Title: Clay paving tiles; Uniclass2015Version: Products v1.31; Version: 5
Type - NBS_Data - Colour: Cocoa; PlanShape: Rectangular; SizeMinimum: 1202 x 141 mm; ThicknessMinimum: 26 mm; TileMaterial: Porcelain; ContainsRedListMaterials: No; CountryOfMaterialOrigin: Italy; CountryOfProductManufacture: Italy; Recyclability: 100; RecycledContent: 0; WaterAbsorption: To ISO 10545-3, ≤0.5%; AbrasionResistance: To ISO 10545-7, 5; SlipResistance: R11
Classification: Pr_25_93_60_10 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:NBS_Raaft_ClayPavingTiles_FarrinoPorcelainDecking_FarrinoFlax, Floor:NBS_Raaft_ClayPavingTiles_FarrinoPorcelainDecking_FarrinoFlax:221867
In: Level 0
Type - PredefinedType: FLOORING; Material: NBS_Raaft_ClayPavingTiles_FarrinoPorcelainDecking_FarrinoFlax 26 mm
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: FLOORING
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_25_93_60_10:Clay paving tiles; Color: Beige,Brown,Grey,Silver,Other; Finish: Wood grain; Material: Porcelain; Shape: Rectangle; Size: 1202 x 141 x 26 mm; WarrantyDescription: 15 year; CodePerformance: ISO 10545-3, ISO 10545-7; Constituents: n/a; Description: Natural wood effect porcelain decking boards; DurationUnit: year; ExpectedLife: n/a; Features: Class A fire-rated, high abrasion and frost resistance, anti-slip, thermostable, highly resistant to stains; Grade: n/a; Manufacturer: enquiries@raaft.co; ModelNumber: n/a; ModelReference: n/a; Name: ClayPavingTiles_FarrinoPorcelainDecking_FarrinoFlax_Raaft; NominalHeight: 26 mm; NominalLength: 1202 mm; NominalWidth: 141 mm; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_Raaft_ClayPavingTiles_FarrinoPorcelainDecking_FarrinoFlax; ManufacturerName: Raaft; ManufacturerURL: www.raaft.co; ProductInformation: https://source.thenbs.com/product/-/2d21df91-2c1e-40e3-9def-9decae13e560/d00127ab-95ce-48b0-97fa-c07815e56af3; Uniclass2015Code: Pr_25_93_60_10; Uniclass2015Title: Clay paving tiles; Uniclass2015Version: Products v1.31; Version: 5
Type - NBS_Data - Colour: Flax; PlanShape: Rectangular; SizeMinimum: 1202 x 141 mm; ThicknessMinimum: 26 mm; TileMaterial: Porcelain; ContainsRedListMaterials: No; CountryOfMaterialOrigin: Italy; CountryOfProductManufacture: Italy; Recyclability: 100; RecycledContent: 0; WaterAbsorption: To ISO 10545-3, ≤0.5%; AbrasionResistance: To ISO 10545-7, 5; SlipResistance: R11
Classification: Pr_25_93_60_10 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:NBS_Raaft_ClayPavingTiles_FarrinoPorcelainDecking_FarrinoMogno, Floor:NBS_Raaft_ClayPavingTiles_FarrinoPorcelainDecking_FarrinoMogno:221883
In: Level 0
Type - PredefinedType: FLOORING; Material: NBS_Raaft_ClayPavingTiles_FarrinoPorcelainDecking_FarrinoMogno 26 mm
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: FLOORING
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_25_93_60_10:Clay paving tiles; Color: Beige,Brown,Grey,Silver,Other; Finish: Wood grain; Material: Porcelain; Shape: Rectangle; Size: 1202 x 141 x 26 mm; WarrantyDescription: 15 year; CodePerformance: ISO 10545-3, ISO 10545-7; Constituents: n/a; Description: Natural wood effect porcelain decking boards; DurationUnit: year; ExpectedLife: n/a; Features: Class A fire-rated, high abrasion and frost resistance, anti-slip, thermostable, highly resistant to stains; Grade: n/a; Manufacturer: enquiries@raaft.co; ModelNumber: n/a; ModelReference: n/a; Name: ClayPavingTiles_FarrinoPorcelainDecking_FarrinoMogno_Raaft; NominalHeight: 26 mm; NominalLength: 1202 mm; NominalWidth: 141 mm; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_Raaft_ClayPavingTiles_FarrinoPorcelainDecking_FarrinoMogno; ManufacturerName: Raaft; ManufacturerURL: www.raaft.co; ProductInformation: https://source.thenbs.com/product/-/2d21df91-2c1e-40e3-9def-9decae13e560/d00127ab-95ce-48b0-97fa-c07815e56af3; Uniclass2015Code: Pr_25_93_60_10; Uniclass2015Title: Clay paving tiles; Uniclass2015Version: Products v1.31; Version: 5
Type - NBS_Data - Colour: Mogno; PlanShape: Rectangular; SizeMinimum: 1202 x 141 mm; ThicknessMinimum: 26 mm; TileMaterial: Porcelain; ContainsRedListMaterials: No; CountryOfMaterialOrigin: Italy; CountryOfProductManufacture: Italy; Recyclability: 100; RecycledContent: 0; WaterAbsorption: To ISO 10545-3, ≤0.5%; AbrasionResistance: To ISO 10545-7, 5; SlipResistance: R11
Classification: Pr_25_93_60_10 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:NBS_Raaft_ClayPavingTiles_FarrinoPorcelainDecking_FarrinoOak, Floor:NBS_Raaft_ClayPavingTiles_FarrinoPorcelainDecking_FarrinoOak:221899
In: Level 0
Type - PredefinedType: FLOORING; Material: NBS_Raaft_ClayPavingTiles_FarrinoPorcelainDecking_FarrinoOak 26 mm
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: FLOORING
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_25_93_60_10:Clay paving tiles; Color: Beige,Brown,Grey,Silver,Other; Finish: Wood grain; Material: Porcelain; Shape: Rectangle; Size: 1202 x 141 x 26 mm; WarrantyDescription: 15 year; CodePerformance: ISO 10545-3, ISO 10545-7; Constituents: n/a; Description: Natural wood effect porcelain decking boards; DurationUnit: year; ExpectedLife: n/a; Features: Class A fire-rated, high abrasion and frost resistance, anti-slip, thermostable, highly resistant to stains; Grade: n/a; Manufacturer: enquiries@raaft.co; ModelNumber: n/a; ModelReference: n/a; Name: ClayPavingTiles_FarrinoPorcelainDecking_FarrinoOak_Raaft; NominalHeight: 26 mm; NominalLength: 1202 mm; NominalWidth: 141 mm; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_Raaft_ClayPavingTiles_FarrinoPorcelainDecking_FarrinoOak; ManufacturerName: Raaft; ManufacturerURL: www.raaft.co; ProductInformation: https://source.thenbs.com/product/-/2d21df91-2c1e-40e3-9def-9decae13e560/d00127ab-95ce-48b0-97fa-c07815e56af3; Uniclass2015Code: Pr_25_93_60_10; Uniclass2015Title: Clay paving tiles; Uniclass2015Version: Products v1.31; Version: 5
Type - NBS_Data - Colour: Oak; PlanShape: Rectangular; SizeMinimum: 1202 x 141 mm; ThicknessMinimum: 26 mm; TileMaterial: Porcelain; ContainsRedListMaterials: No; CountryOfMaterialOrigin: Italy; CountryOfProductManufacture: Italy; Recyclability: 100; RecycledContent: 0; WaterAbsorption: To ISO 10545-3, ≤0.5%; AbrasionResistance: To ISO 10545-7, 5; SlipResistance: R11
Classification: Pr_25_93_60_10 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:NBS_Raaft_ClayPavingTiles_FarrinoPorcelainDecking_FarrinoPearl, Floor:NBS_Raaft_ClayPavingTiles_FarrinoPorcelainDecking_FarrinoPearl:221915
In: Level 0
Type - PredefinedType: FLOORING; Material: NBS_Raaft_ClayPavingTiles_FarrinoPorcelainDecking_FarrinoPearl 26 mm
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: FLOORING
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_25_93_60_10:Clay paving tiles; Color: Beige,Brown,Grey,Silver,Other; Finish: Wood grain; Material: Porcelain; Shape: Rectangle; Size: 1202 x 141 x 26 mm; WarrantyDescription: 15 year; CodePerformance: ISO 10545-3, ISO 10545-7; Constituents: n/a; Description: Natural wood effect porcelain decking boards; DurationUnit: year; ExpectedLife: n/a; Features: Class A fire-rated, high abrasion and frost resistance, anti-slip, thermostable, highly resistant to stains; Grade: n/a; Manufacturer: enquiries@raaft.co; ModelNumber: n/a; ModelReference: n/a; Name: ClayPavingTiles_FarrinoPorcelainDecking_FarrinoPearl_Raaft; NominalHeight: 26 mm; NominalLength: 1202 mm; NominalWidth: 141 mm; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_Raaft_ClayPavingTiles_FarrinoPorcelainDecking_FarrinoPearl; ManufacturerName: Raaft; ManufacturerURL: www.raaft.co; ProductInformation: https://source.thenbs.com/product/-/2d21df91-2c1e-40e3-9def-9decae13e560/d00127ab-95ce-48b0-97fa-c07815e56af3; Uniclass2015Code: Pr_25_93_60_10; Uniclass2015Title: Clay paving tiles; Uniclass2015Version: Products v1.31; Version: 5
Type - NBS_Data - Colour: Pearl; PlanShape: Rectangular; SizeMinimum: 1202 x 141 mm; ThicknessMinimum: 26 mm; TileMaterial: Porcelain; ContainsRedListMaterials: No; CountryOfMaterialOrigin: Italy; CountryOfProductManufacture: Italy; Recyclability: 100; RecycledContent: 0; WaterAbsorption: To ISO 10545-3, ≤0.5%; AbrasionResistance: To ISO 10545-7, 5; SlipResistance: R11
Classification: Pr_25_93_60_10 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:NBS_Raaft_ClayPavingTiles_FarrinoPorcelainDecking_FarrinoSmoke, Floor:NBS_Raaft_ClayPavingTiles_FarrinoPorcelainDecking_FarrinoSmoke:221931
In: Level 0
Type - PredefinedType: FLOORING; Material: NBS_Raaft_ClayPavingTiles_FarrinoPorcelainDecking_FarrinoSmoke 26 mm
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: FLOORING
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_25_93_60_10:Clay paving tiles; Color: Beige,Brown,Grey,Silver,Other; Finish: Wood grain; Material: Porcelain; Shape: Rectangle; Size: 1202 x 141 x 26 mm; WarrantyDescription: 15 year; CodePerformance: ISO 10545-3, ISO 10545-7; Constituents: n/a; Description: Natural wood effect porcelain decking boards; DurationUnit: year; ExpectedLife: n/a; Features: Class A fire-rated, high abrasion and frost resistance, anti-slip, thermostable, highly resistant to stains; Grade: n/a; Manufacturer: enquiries@raaft.co; ModelNumber: n/a; ModelReference: n/a; Name: ClayPavingTiles_FarrinoPorcelainDecking_FarrinoSmoke_Raaft; NominalHeight: 26 mm; NominalLength: 1202 mm; NominalWidth: 141 mm; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_Raaft_ClayPavingTiles_FarrinoPorcelainDecking_FarrinoSmoke; ManufacturerName: Raaft; ManufacturerURL: www.raaft.co; ProductInformation: https://source.thenbs.com/product/-/2d21df91-2c1e-40e3-9def-9decae13e560/d00127ab-95ce-48b0-97fa-c07815e56af3; Uniclass2015Code: Pr_25_93_60_10; Uniclass2015Title: Clay paving tiles; Uniclass2015Version: Products v1.31; Version: 5
Type - NBS_Data - Colour: Smoke; PlanShape: Rectangular; SizeMinimum: 1202 x 141 mm; ThicknessMinimum: 26 mm; TileMaterial: Porcelain; ContainsRedListMaterials: No; CountryOfMaterialOrigin: Italy; CountryOfProductManufacture: Italy; Recyclability: 100; RecycledContent: 0; WaterAbsorption: To ISO 10545-3, ≤0.5%; AbrasionResistance: To ISO 10545-7, 5; SlipResistance: R11
Classification: Pr_25_93_60_10 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
